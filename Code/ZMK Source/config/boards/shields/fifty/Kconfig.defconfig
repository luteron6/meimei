## Code/ZMK Source/config/boards/shields/fifty/Kconfig.defconfig
```kconfig
if SHIELD_MEIMEI

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "MeiMei"

endif
```
